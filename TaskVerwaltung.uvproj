# Keil uVision project TaskVerwaltung.uvproj, settings and files
target Target 1 (MCS-51)
  device: C517A-4R Infineon
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: TaskVerwaltung
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: prozesse.a51 betriebssystem.a51
